## config/boards/shields/milk2/Kconfig.defconfig
```kconfig
if SHIELD_MILK2
config ZMK_KEYBOARD_NAME
    string
    default "Milk2 Wireless"
endif
```
